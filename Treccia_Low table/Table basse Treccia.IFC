Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Table basse Treccia.IFC
Time: 2023-07-26T07:55:13
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 105392_Default (18)
In: Default Storey
Name
105392_Default | PSet_Mass_Property - Mass Measure: 28.0743; Area Measure: 1.92502 m2; Volume Measure: 0.00364602 m3
17 x 105392_Default
